ORG 000H
MOV TMOD,#20H
MOV TH1,#-6
MOV SCON,#50H
MOV P2, #11111111B
SETB TR1
MOV R1,#15
MOV DPTR,#MYDATA
LOOP: CLR A
MOVC A,@A+DPTR
MOV SBUF,A
HERE:JNB TI,HERE
CLR TI
INC DPTR
DJNZ R1,LOOP
;-------------------
AGAIN:JNB RI,AGAIN
MOV A,SBUF
MOV P1,A
CLR RI
;-------------------
MOV A,P2
MOV SBUF,A
THIS: JNB TI,THIS
CLR TI
SJMP AGAIN
MYDATA: DB 'ARPIT 19BEC0358'
END